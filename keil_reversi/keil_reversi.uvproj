# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 oTime=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c timer0.c timer0.h gestor_pulsacion.c gestor_pulsacion.h gestor_alarmas.h cola.c cola.h planificador.c planificador.h gestor_alarmas.c gestor_SC.s gestor_IO.c gestor_IO.h tableros.h Actualizar.s Actualizar_Propagar.s propagar.s gestor_RTC.h celda.h eventos.h gpio.c gpio.h sudoku_2021.h sudoku_2021.c gestor_RTC.c gestor_WD.c gestor_WD.h SWI.s SWI_functions.h serial_port.c serial_port.h gestor_UART.c gestor_UART.h funciones_escritura.c funciones_escritura.h eint_init.c eint_init.h gestor_energia.h gestor_energia.c
